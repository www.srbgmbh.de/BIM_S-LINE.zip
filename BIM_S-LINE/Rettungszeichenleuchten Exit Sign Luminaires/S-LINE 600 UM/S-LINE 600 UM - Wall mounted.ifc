Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: ad87f439-aa84-49b4-bd35-2ceafd7820dc, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: 2018_01
Time: 2024-03-05T13:21:47+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.1.24 - Exporter 23.2.1.0 - Alternativ-UI 23.2.1.0

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: S-LINE 600 UM - Wall mounted:S-LINE 600 UM - 930 lm - Einzelbatterie, S-LINE 600 UM - Wall mounted:S-LINE 600 UM - 930 lm - Einzelbatterie:2487302
In: Default
Type - Material: RAL 9016
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: S-LINE 600 UM - 930 lm - Einzelbatterie; sets with these values: 2
